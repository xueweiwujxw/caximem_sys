SRC_URI += "file://user_2022-09-21-10-03-00.cfg \
            file://user_2022-09-22-12-47-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

